options:
  parameters:
    generate_options: qt_gui
    id: FM_transmit
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fm_station
  id: variable
  parameters:
    value: int(92.5e6)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(576e3)
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(48e3)
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(576e3)
    tau: '75e-6'
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/maryam/Downloads/sound_track.wav
    repeat: 'True'
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '20.0'
    auto_filter: 'True'
    bandwidth: samp_rate
    buffer_size: '32768'
    cyclic: 'False'
    frequency: fm_station
    samplerate: samp_rate
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_HAMMING
  states: {}

connections:
- [analog_wfm_tx_0, '0', iio_pluto_sink_0, '0']
- [analog_wfm_tx_0, '0', qtgui_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
